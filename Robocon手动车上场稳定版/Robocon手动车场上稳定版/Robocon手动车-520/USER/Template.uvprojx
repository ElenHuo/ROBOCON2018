# Keil uVision project Template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\APP;..\BSP
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_hash.c stm32f4xx_iwdg.c stm32f4xx_can.c stm32f4xx_exti.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group README
    ../: readme.txt
  group BSP
    ../BSP/: timer2.c timer2.h protocol.c protocol.h Encoder.c Encoder.h iwdg.c iwdg.h can1.c can1.h can2.c can2.h pstwo.h uart4_FireRC.c uart4_FireRC.h scope.c scope.h Ras_usart.c led.c led.h exti.c switch.c gyro_uart.c pstwo_line.c
  group APP
    ../APP/: task.c task.h positioning.c positioning.h Chassis.c Chassis.h kalman.h PID.c PID.h fs_pid.c fs_pid.h point_to_point.c Remote_Control.c WFLY_REMOTE.c global_localization.c Servo.c PS2_TASK.c REMOTE_TASK.c
